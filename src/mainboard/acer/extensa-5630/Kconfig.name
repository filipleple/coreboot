## src/mainboard/acer/extensa-5630/Kconfig.name
```kconfig
## SPDX-License-Identifier: GPL-2.0-only

config BOARD_ACER_EXTENSA_5630
	bool "Extensa 5630"
```
